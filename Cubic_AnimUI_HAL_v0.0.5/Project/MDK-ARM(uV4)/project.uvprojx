# Keil uVision project project.uvprojx, settings and files
target STM32F429 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F429ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(180000000) ELITTLE
  output: output
  AfterMake: fromelf --bin .\Flash\Obj\@L.axf --output .\bin\cubic.bin
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F429xx,__CC_ARM
  c misc: --diag_suppress=870
  c include: ..\..\Libraries\CMSIS\Include;..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\User;..\..\emWin\Include;..\..\emWin\emWinTask;..\..\emWin\Config;..\..\emWin\PNG;..\..\User\font;..\..\User\AnimUIDemo\ALDES;..\..\User\sensor_sample;..\..\User\wifi;..\..\User\cjson;..\..\User\Azure\azure_c_shared_utility;..\..\User\AnimUIDemo\ANIMATION_Basics;..\..\User\bsp_hal;..\..\Libraries\STM32F4xx_HAL_Driver\Inc;..\..\UCOSIII\uC-CPU;..\..\UCOSIII\uC-LIB;..\..\UCOSIII\UCOS-BSP;..\..\UCOSIII\UCOS-CONFIG;..\..\UCOSIII\uCOS-III\Source;..\..\UCOSIII\uC-CPU\ARM-Cortex-M4\RealView;..\..\UCOSIII\uC-LIB\Ports\ARM-Cortex-M4\RealView;..\..\UCOSIII\uCOS-III\Ports\ARM-Cortex-M4\Generic\RealView;..\..\User\bsp_hal\delay;..\..\User\bsp_hal\sys;..\..\User\usb\Middlewares\ST\STM32_USB_Device_Library\Core\Inc;..\..\User\usb\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Inc;..\..\User\usb\Inc;..\..\User\easyflash\inc;..\..\User\easylogger\inc;..\..\User\easylogger\plugins\flash;..\..\User\cm_backtrace;..\..\User\cm_backtrace\fault_handler;..\..\User\easylogger;..\..\User\sensor_sample\voc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../../User/: main.c
    ../../User/bsp_hal/: stm32f4xx_it.c
  group BSP
    ../../User/bsp_hal/: bsp.c bsp.h stm32f429i_discovery.c stm32f429i_discovery_sdram.c ili9806g.c bsp_tim_pwm.c bsp_uart_fifo.c ringbuffer.c stm32f4xx_hal_msp.c tty.c bsp_spi_bus.c bsp_spi_flash.c I2C_simulation.c HT1080.c bsp_adc.c touch_key.c bsp_RNG.c
    ../../User/: types.h bsp_os.c
    ../../User/wifi/: HFLPT230.c
    ../../User/bsp_hal/sys/: sys.c
    ../../User/bsp_hal/delay/: delay.c
    ../../User/sensor_sample/: sensor_measure.c
    ../../User/sensor_sample/voc/: vocTask.c
  group MDK-ARM
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f429xx.s
  group CMSIS
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group STM32F4xx_HAL_Driver
    ../../Libraries/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_sdram.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_crc.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_ll_fmc.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_ll_usb.c stm32f4xx_hal_rng.c
  group uC/CPU
    ../../UCOSIII/uC-CPU/ARM-Cortex-M4/RealView/: cpu_a.asm cpu_c.c
    ../../UCOSIII/uC-CPU/: cpu_core.c
  group uC/LIB
    ../../UCOSIII/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
    ../../UCOSIII/uC-LIB/Ports/ARM-Cortex-M4/RealView/: lib_mem_a.asm
  group uC/OS-III Source
    ../../UCOSIII/uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group uC/OS-III Port
    ../../UCOSIII/uCOS-III/Ports/ARM-Cortex-M4/Generic/RealView/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group uC/OS-III Config
    ../../User/: app_cfg.h
    ../../UCOSIII/UCOS-CONFIG/: cpu_cfg.h includes.h lib_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h
  group GUI_X
    ../../emWin/GUI_X/: GUI_X_uCOS-III.c
  group GUI/Config
    ../../emWin/Config_disco/: GUIConf.c LCDConf_stm32f429i_disco_MB1075.c
  group GUI/DEMO
    ../../User/AnimUIDemo/ANIMATION_Basics/: ANIMATION_Basics.c
    ../../User/AnimUIDemo/ALDES/: MOTION_MovingWindow.c
  group GUI/Lib
    ../../emWin/GUILib/: STemWin532_CM4_OS_Keil_ot.lib STemWin540_CM4_Keil.lib
  group cjson
    ../../User/cjson/: cJSON.c cJSON_APP.c
  group font
    ../../User/AnimUIDemo/ANIMATION_Basics/: HelveticaNeueLT Pro 45 Lt35.c HelveticaNeueLT Pro 45 Lt41.c HelveticaNeueLT Pro 65 Md36.c HelveticaNeueLT Pro 65 Md38.c HelveticaNeueLT Pro 65 Md41.c HelveticaNeueLT Pro 65 Md43.c HelveticaNeueLT Pro 65 Md48.c HelveticaNeueLT Pro 65 Md56.c HelveticaNeueLT Pro 65 Md75.c HelveticaNeueLT Pro 65 Md113.c Pingfang_Cuti72.c
    ../../User/fonts/: HelveticaNeueLT Pro 65 Md147.c
  group azure
    ../../User/Azure/src/: hmac.c sha1.c sha224.c sha384-512.c usha.c base64.c buffer.c strings.c
  group Usb_Device
    ../../User/usb/Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../../User/usb/Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
    ../../User/usb/Src/: usb_device.c usbd_cdc_if.c usbd_conf.c usbd_desc.c
  group easyflash
    ../../User/easyflash/src/: easyflash.c ef_env.c ef_env_wl.c ef_utils.c ef_log.c
    ../../User/easyflash/port/: ef_port.c
    ../../User/easyflash/: env_test.c
  group cm_backtrace
    ../../User/cm_backtrace/: cm_backtrace.c cmb_cfg.h fault_test.c
    ../../User/cm_backtrace/fault_handler/keil/: cmb_fault.S
  group Doc
    ../../Doc/: 软件开发进度.txt
software components: CMSIS:CORE 3.20.0, Device:Startup 1.3.1
